/* ESP32-C3 TRM, главы LEDC и SAR ADC. Та же раскладка, что в регистровом стенде. */
.section .text.start, "ax", @progbits
.globl _start
_start:
    li s0, 0x60019000
    li s1, 0x60040000
    li s2, 0x60004000
    li t0, 1
    sw t0, 0xd0(s0)      /* LEDC питается от APB, 80 МГц. */
    li t0, 0x02001008   /* обновление, делитель 256/256, разрядность 8. */
    sw t0, 0xa0(s0)
    li t0, 0x14
    sw t0, 0(s0)
    li t0, 0x60009014   /* IO_MUX GPIO4, функция матрицы. */
    li t1, 0x1000
    sw t1, 0(t0)
    li t0, 45
    sw t0, 0x564(s2)     /* GPIO4 ← LEDC_LS_SIG_OUT0_IDX. */
    li s3, 0x81800000   /* ADC1 канал 0, ослабление 3. */
    li s4, 0xa1800000   /* Та же настройка с запуском преобразования. */
    li s5, 0x80000000
    li s6, 4095
    li s7, 93           /* Порог обрыва 0.1 В: V · 0.25 / 1.1 · 4095. */
    li s8, 2028         /* Уставка 1.10 рад: (0.2+1.8·q) · 0.25/1.1 · 4095. */
    li s10, 0           /* Счётчик преобразований контрольного образа. */
    li s9, 255          /* Верхний код 8-битного ШИМ. */
1:
    sw s3, 0x20(s1)
    sw s4, 0x20(s1)
2:
    lw t0, 0x44(s1)
    bgez t0, 2b
    lw t0, 0x2c(s1)
    and t0, t0, s6
.ifdef IGNORE_SENSOR
    /* Два уровня 1/4 и 3/4 периода. Отсчёт читается, но выход меняется
     * только по счётчику, примерно каждые 4096 преобразований ADC. */
    addi s10, s10, 1
    srli t1, s10, 12
    andi t1, t1, 1
    slli t1, t1, 7
    addi t1, t1, 64
    j 4f
.endif
    li t1, 0
    bgeu s7, t0, 4f
    bgeu t0, s8, 4f
    sub t1, s8, t0
    bltu t1, s9, 4f
    mv t1, s9
4:
    slli t1, t1, 4
    sw t1, 8(s0)
    sw s5, 0xc(s0)
    j 1b
